# Keil uVision project lockGW.uvprojx, settings and files
target lockGW (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LockGW +hex
  c flags: Optim=1 uC99=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL
  c include: ..\Lib\inc;..\Lib\cmsis;..\user;..\Lib;..\Drivers\inc;..\Modules\aes;..\app\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../user/: main.c stm32f10x_it.c system_stm32f10x.c driversInit.c process.c lora_com.c temp.c
    ../Modules/aes/: aes.c
  group Library
    ../Lib/cmsis/: core_cm3.c
    ../Lib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_spi.c
    ../lib/src/: stm32f10x_exti.c stm32f10x_dma.c stm32f10x_iwdg.c stm32f10x_flash.c
  group Startup
    ../lib/startup/arm/: startup_stm32f10x_cl.s
  group Drivers
    ../Drivers/src/: Delay.c
    ../drivers/src/: usart.c led.c SPI.c SX1276.C Ethernet.c button.c flash.c
  group APP
    ../app/src/: schd.c GlobalVar.c CRC32.c
